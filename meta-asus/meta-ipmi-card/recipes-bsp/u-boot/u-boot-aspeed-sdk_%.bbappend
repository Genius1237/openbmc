FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-ARM-dts-aspeed-Add-ASUS-IPMI-card-DTS.patch \
    "
